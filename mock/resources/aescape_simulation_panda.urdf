Commit message: remove mystery mass from end effector

File: mock/resources/aescape_simulation_panda.urdf (robot description, URDF)
Before this commit: robot panda, 10 links, 9 joints
Links:
- link panda_link8: mass 0.435 -> 0.0
